DESCRIPTION = "Bootlin lab games"

inherit packagegroup

SUMMARY_${PN} = "Lab games"
RDEPENDS:${PN} = "ninvaders"
