require bootlinlabs-image-minimal.bb

DESCRIPTION = "The bootlinlabs-image-minimal with extra debugging"

IMAGE_FEATURES += "dbg-pkgs"
